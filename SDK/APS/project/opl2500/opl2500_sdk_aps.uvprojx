# Keil uVision project opl2500_sdk_aps.uvprojx, settings and files
target OPL2500_APS_SDK (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: opl2500_sdk_aps +hex (library)
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL2500_APS OPL2500_PATCH __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WIFI_MAC_TASK__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ MBEDTLS_CONFIG_FILE="<config-opl-default.h>"
  c misc: --preinclude=sys_common.h
  c include: .\boot_sequence;.\include;.\lib;.\startup;..\common;..\..\FreeRtos;..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\driver\CMSIS\Include;..\..\driver\chip;..\..\driver\chip\opl2500\camera;..\..\driver\chip\opl2500\hal_auxadc;..\..\driver\chip\opl2500\hal_dbg_uart;..\..\driver\chip\opl2500\hal_dma;..\..\driver\chip\opl2500\hal_gpio;..\..\driver\chip\opl2500\hal_i2c;..\..\driver\chip\opl2500\hal_patch;..\..\driver\chip\opl2500\hal_pdm;..\..\driver\chip\opl2500\hal_pwm;..\..\driver\chip\opl2500\hal_spi;..\..\driver\chip\opl2500\hal_system;..\..\driver\chip\opl2500\hal_tick;..\..\driver\chip\opl2500\hal_tmr;..\..\driver\chip\opl2500\hal_uart;..\..\driver\chip\opl2500\hal_vic;..\..\driver\chip\opl2500\hal_wdt;..\..\driver\chip\opl2500\securityipdriver;..\..\middleware\netlink;..\..\middleware\netlink\at;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\cli;..\..\middleware\netlink\common\sys_api;..\..\middleware\netlink\common\sys_api\rom_if;..\..\middleware\netlink\common\sys_ctrl;..\..\middleware\netlink\controller_task;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\diag_task;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\msg;..\..\middleware\netlink\mw_fim;..\..\middleware\netlink\mw_ota;..\..\middleware\netlink\ps_task;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\wifi_mac;..\..\middleware\netlink\wifi_mac\common;..\..\middleware\third_party\httpclient;..\..\middleware\third_party\lwip-2.0.3;..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\middleware\third_party\mbedtls\configs;..\..\middleware\third_party\mbedtls\include;..\..\middleware\third_party\mbedtls\include\mbedtls;..\..\middleware\third_party\mbedtls\port\include;..\..\middleware\third_party\tinycrypt\include;..\..\middleware\third_party\tinycrypt\include\tinycrypt;..\..\apps\le_app\cmd_app;..\..\apps\le_app\pts_app;..\..\..\APS_PATCH\project\opl2500\boot_sequence;..\..\..\APS_PATCH\project\opl2500\include;..\..\..\APS_PATCH\project\opl2500\lib;..\..\..\APS_PATCH\project\opl2500\startup;..\..\..\APS_PATCH\project\common;..\..\..\APS_PATCH\FreeRtos;..\..\..\APS_PATCH\FreeRtos\Source\include;..\..\..\APS_PATCH\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\..\APS_PATCH\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\APS_PATCH\driver\CMSIS\Include;..\..\..\APS_PATCH\driver\chip;..\..\..\APS_PATCH\driver\chip\opl2500\camera;..\..\..\APS_PATCH\driver\chip\opl2500\hal_auxadc;..\..\..\APS_PATCH\driver\chip\opl2500\hal_dbg_uart;..\..\..\APS_PATCH\driver\chip\opl2500\hal_dma;..\..\..\APS_PATCH\driver\chip\opl2500\hal_gpio;..\..\..\APS_PATCH\driver\chip\opl2500\hal_i2c;..\..\..\APS_PATCH\driver\chip\opl2500\hal_patch;..\..\..\APS_PATCH\driver\chip\opl2500\hal_pdm;..\..\..\APS_PATCH\driver\chip\opl2500\hal_pwm;..\..\..\APS_PATCH\driver\chip\opl2500\hal_spi;..\..\..\APS_PATCH\driver\chip\opl2500\hal_system;..\..\..\APS_PATCH\driver\chip\opl2500\hal_tick;..\..\..\APS_PATCH\driver\chip\opl2500\hal_tmr;..\..\..\APS_PATCH\driver\chip\opl2500\hal_uart;..\..\..\APS_PATCH\driver\chip\opl2500\hal_vic;..\..\..\APS_PATCH\driver\chip\opl2500\hal_wdt;..\..\..\APS_PATCH\driver\chip\opl2500\securityipdriver;..\..\..\APS_PATCH\middleware\netlink;..\..\..\APS_PATCH\middleware\netlink\at;..\..\..\APS_PATCH\middleware\netlink\ble_controller_layer\inc;..\..\..\APS_PATCH\middleware\netlink\cli;..\..\..\APS_PATCH\middleware\netlink\common\sys_api;..\..\..\APS_PATCH\middleware\netlink\common\sys_api\rom_if;..\..\..\APS_PATCH\middleware\netlink\common\sys_ctrl;..\..\..\APS_PATCH\middleware\netlink\controller_task;..\..\..\APS_PATCH\middleware\netlink\data_flow;..\..\..\APS_PATCH\middleware\netlink\diag_task;..\..\..\APS_PATCH\middleware\netlink\le_stack;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\mw_fim;..\..\..\APS_PATCH\middleware\netlink\mw_ota;..\..\..\APS_PATCH\middleware\netlink\ps_task;..\..\..\APS_PATCH\middleware\netlink\wifi_controller_layer;..\..\..\APS_PATCH\middleware\netlink\wifi_mac;..\..\..\APS_PATCH\middleware\netlink\wifi_mac\common;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\APS_PATCH\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\..\APS_PATCH\middleware\third_party\mbedtls\configs;..\..\..\APS_PATCH\middleware\third_party\mbedtls\include;..\..\..\APS_PATCH\middleware\third_party\mbedtls\include\mbedtls;..\..\..\APS_PATCH\middleware\third_party\mbedtls\port\include;..\..\..\APS_PATCH\middleware\third_party\tinycrypt\include;..\..\..\APS_PATCH\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\APS_PATCH\apps\le_app\cmd_app;..\..\..\APS_PATCH\apps\le_app\include;..\..\..\APS_PATCH\apps\le_app\pts_app;..\..\middleware\third_party\wpa_supplicant;..\..\middleware\third_party\wpa_supplicant\port\include;..\..\middleware\third_party\wpa_supplicant\src;..\..\..\APS_PATCH\middleware\netlink\le_stack\patch
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ../../../APS_PATCH/project/opl2500/startup/: sys_init_patch.c irq_patch.c
  group Driver
    ../../../APS_PATCH/driver/chip/opl2500/hal_system/: hal_system_patch.c hal_sys_rcc_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_auxadc/: hal_auxadc_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_spi/: hal_flash_patch.c hal_qspi_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_gpio/: hal_pin_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_vic/: hal_vic_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_uart/: hal_uart_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_dma/: hal_dma_patch.c
  group lwip
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/: lwip_helper_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/rom_if/: lwip_jmptbl_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/lwip/src/core/: memp_patch.c pbuf_patch.c
    ../../../APS_PATCH/middleware/third_party/lwip-2.0.3/ports/freertos/netif/: wlannetif_patch.c
  group http_client
    ../../middleware/third_party/httpclient/: httpclient.c
  group mw_fim
    ../../../APS_PATCH/middleware/netlink/mw_fim/: mw_fim_patch.c mw_fim_default_group01_patch.c mw_fim_default_group02_patch.c
  group common
    ../../../APS_PATCH/middleware/netlink/common/sys_ctrl/: sys_common_ctrl_patch.c
  group object
    ../../middleware/third_party/wpa_supplicant/project/lib/: wpa_supplicant.lib
