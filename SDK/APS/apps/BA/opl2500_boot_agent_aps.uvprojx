# Keil uVision project opl2500_boot_agent_aps.uvprojx, settings and files
target OPL2500_APS_Boot_Agent (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: opl2500_boot_agent_aps +hex
  AfterMake: opl2500_boot_agent_aps.bat $L @L ..\..\..\
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL2500_APS OPL2500_PATCH __noOPL2500_EXT_FLASH __noSIMULATOR__ __BLE__ __LE_HOST_USE_CMD__ __LWIP_TASK__ __WPA_SUPPLICANT__ __noHW_CRYPTO_ENGINE__ __WIFI_MAC_TASK__ __NL1000_An__ __PMP_ENABLE__ __PMP_REGION__ __HEAP_REGION__ noLWIP_DYNAMIC_DEBUG_ENABLE __AT_CMD_TASK__ __noRTL_SIMULATION__ __WIFI_AUTO_CONNECT__
  c misc: --preinclude=sys_common.h
  c include: ..\..\FreeRtos\Source\include;..\..\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\driver\CMSIS\Include;..\..\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\driver\chip;..\..\driver\chip\opl2500\securityipdriver;..\..\driver\chip\opl2500\hal_auxadc;..\..\driver\chip\opl2500\hal_system;..\..\driver\chip\opl2500\hal_patch;..\..\driver\chip\opl2500\hal_uart;..\..\driver\chip\opl2500\hal_spi;..\..\driver\chip\opl2500\hal_vic;..\..\driver\chip\opl2500\hal_dbg_uart;..\..\driver\chip\opl2500\hal_wdt;..\..\driver\chip\opl2500\hal_dma;..\..\driver\chip\opl2500\hal_tmr;..\..\driver\chip\opl2500\hal_tick;..\..\driver\chip\opl2500\hal_pwm;..\..\driver\chip\opl2500\hal_i2c;..\..\driver\chip\opl2500\hal_gpio;..\..\project\opl2500\include;..\..\project\common;..\..\middleware\netlink;..\..\middleware\netlink\cli;..\..\middleware\netlink\msg;..\..\middleware\netlink\data_flow;..\..\middleware\netlink\wifi_controller_layer;..\..\middleware\netlink\wifi_controller_layer\rom_if;..\..\middleware\netlink\ble_controller_layer\inc;..\..\middleware\netlink\le_stack;..\..\middleware\netlink\at;..\..\middleware\netlink\iperf\inc;..\..\middleware\netlink\controller_task;..\..\middleware\netlink\ps_task;..\..\middleware\netlink\diag_task;..\..\middleware\netlink\wifi_mac;..\..\middleware\netlink\mw_fim;..\..\middleware\netlink\mw_ota;..\..\project\opl2500\boot_sequence;..\..\project\opl2500\startup;..\..\project\opl2500\include;..\..\..\APS_PATCH\middleware\netlink\msg;..\..\..\APS_PATCH\middleware\netlink\ps_task;..\..\..\APS_PATCH\project\opl2500\include;..\..\..\APS_PATCH\project\opl2500\boot_sequence;..\..\..\APS_PATCH\driver\chip;..\..\..\APS_PATCH\driver\chip\opl2500\securityipdriver;..\..\..\APS_PATCH\driver\chip\opl2500\hal_auxadc;..\..\..\APS_PATCH\driver\chip\opl2500\hal_system;..\..\..\APS_PATCH\driver\chip\opl2500\hal_patch;..\..\..\APS_PATCH\driver\chip\opl2500\hal_uart;..\..\..\APS_PATCH\driver\chip\opl2500\hal_spi;..\..\..\APS_PATCH\driver\chip\opl2500\hal_vic;..\..\..\APS_PATCH\driver\chip\opl2500\hal_dbg_uart;..\..\..\APS_PATCH\driver\chip\opl2500\hal_wdt;..\..\..\APS_PATCH\driver\chip\opl2500\hal_dma;..\..\..\APS_PATCH\driver\chip\opl2500\hal_tmr;..\..\..\APS_PATCH\driver\chip\opl2500\hal_tick;..\..\..\APS_PATCH\driver\chip\opl2500\hal_pwm;..\..\..\APS_PATCH\driver\chip\opl2500\hal_i2c;..\..\..\APS_PATCH\driver\chip\opl2500\hal_gpio;..\..\..\APS_PATCH\middleware\netlink\mw_ota
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\opl2500_boot_agent_aps.sct
  link misc: --datacompressor off --any_contingency --entry=BA_main
  group source
    ./: main_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_uart/: hal_uart_patch.c
    ../../../APS_PATCH/middleware/netlink/mw_ota/: mw_ota_boot_patch.c
    ../../../APS_PATCH/driver/chip/opl2500/hal_spi/: hal_qspi_patch.c hal_cache_patch.c hal_flash_patch.c
  group object
    ../../targets/opl2500/object/: symdefs.o
