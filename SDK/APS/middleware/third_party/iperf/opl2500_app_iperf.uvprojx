# Keil uVision project opl2500_app_iperf.uvprojx, settings and files
target OPL2500_APP_IPERF (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.2.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: opl2500_app_iperf +hex
  AfterMake: .\opl2500_app_aps.bat $L !L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL2500_APS OPL2500_FPGA
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\driver\CMSIS\Include;..\..\..\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\driver\chip\opl2500\hal_patch;..\..\..\driver\chip\opl2500\hal_system;..\..\..\project\opl2500\include;..\..\..\project\opl2500\startup;..\..\..\project\common;..\..\..\FreeRtos\Source\include;..\..\..\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\netlink\msg;..\..\netlink\wifi_controller_layer;..\..\netlink\common\sys_api;..\..\netlink\controller_task;..\..\netlink\wifi_mac;..\..\netlink\data_flow;..\lwip-2.0.3;..\lwip-2.0.3\lwip\src\include;..\lwip-2.0.3\ports\freertos\include;..\wpa_supplicant-0.7.3\src\drivers;..\wpa_supplicant-0.7.3\wpa_supplicant;..\wpa_supplicant-0.7.3\src\common;.\src\components;.\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\opl2500_app_iperf.sct
  link misc: --datacompressor off --any_contingency --entry=__Patch_EntryPoint
  group source
    ./: main_patch.c
    ./src/: iperf_example_main.c cmd_parser.c common_cli.c wifi_cli.c iperf_cli.c iperf.c
    ./src/components/: console.c strerror_util.c
  group object
    ../../../targets/opl2500/Output/Objects/: symdefs_fpga.o opl2500_patch_aps.lib opl2500_sdk_aps.lib
