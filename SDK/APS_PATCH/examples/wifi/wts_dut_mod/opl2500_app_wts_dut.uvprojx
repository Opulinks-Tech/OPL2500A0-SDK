# Keil uVision project opl2500_app_wts_dut.uvprojx, settings and files
target OPL2500_APP_WTS_DUT (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: opl2500_app_wts_dut +hex
  AfterMake: .\opl2500_app_aps.bat $L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL2500_APS OPL2500_PATCH
  c misc: --preinclude=sys_common.h
  c include: ..\..\..\..\APS\project\opl2500\boot_sequence;..\..\..\..\APS\project\opl2500\include;..\..\..\..\APS\project\opl2500\lib;..\..\..\..\APS\project\opl2500\startup;..\..\..\..\APS\project\common;..\..\..\..\APS\FreeRtos;..\..\..\..\APS\FreeRtos\Source\include;..\..\..\..\APS\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\..\..\APS\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\..\APS\driver\CMSIS\Include;..\..\..\..\APS\driver\chip;..\..\..\..\APS\driver\chip\opl2500\camera;..\..\..\..\APS\driver\chip\opl2500\hal_auxadc;..\..\..\..\APS\driver\chip\opl2500\hal_dbg_uart;..\..\..\..\APS\driver\chip\opl2500\hal_dma;..\..\..\..\APS\driver\chip\opl2500\hal_gpio;..\..\..\..\APS\driver\chip\opl2500\hal_i2c;..\..\..\..\APS\driver\chip\opl2500\hal_patch;..\..\..\..\APS\driver\chip\opl2500\hal_pdm;..\..\..\..\APS\driver\chip\opl2500\hal_pwm;..\..\..\..\APS\driver\chip\opl2500\hal_spi;..\..\..\..\APS\driver\chip\opl2500\hal_system;..\..\..\..\APS\driver\chip\opl2500\hal_tick;..\..\..\..\APS\driver\chip\opl2500\hal_tmr;..\..\..\..\APS\driver\chip\opl2500\hal_uart;..\..\..\..\APS\driver\chip\opl2500\hal_vic;..\..\..\..\APS\driver\chip\opl2500\hal_wdt;..\..\..\..\APS\driver\chip\opl2500\securityipdriver;..\..\..\..\APS\middleware\netlink;..\..\..\..\APS\middleware\netlink\at;..\..\..\..\APS\middleware\netlink\ble_controller_layer\inc;..\..\..\..\APS\middleware\netlink\cli;..\..\..\..\APS\middleware\netlink\common\sys_api;..\..\..\..\APS\middleware\netlink\common\sys_api\rom_if;..\..\..\..\APS\middleware\netlink\common\sys_ctrl;..\..\..\..\APS\middleware\netlink\controller_task;..\..\..\..\APS\middleware\netlink\data_flow;..\..\..\..\APS\middleware\netlink\diag_task;..\..\..\..\APS\middleware\netlink\le_stack;..\..\..\..\APS\middleware\netlink\msg;..\..\..\..\APS\middleware\netlink\mw_fim;..\..\..\..\APS\middleware\netlink\mw_ota;..\..\..\..\APS\middleware\netlink\ps_task;..\..\..\..\APS\middleware\netlink\wifi_controller_layer;..\..\..\..\APS\middleware\netlink\wifi_mac;..\..\..\..\APS\middleware\netlink\wifi_mac\common;..\..\..\..\APS\middleware\third_party\httpclient;..\..\..\..\APS\middleware\third_party\lwip-2.0.3;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\lwip\src\include\lwip;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\..\APS\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\..\..\APS\middleware\third_party\mbedtls\configs;..\..\..\..\APS\middleware\third_party\mbedtls\include;..\..\..\..\APS\middleware\third_party\mbedtls\include\mbedtls;..\..\..\..\APS\middleware\third_party\mbedtls\port\include;..\..\..\..\APS\middleware\third_party\tinycrypt\include;..\..\..\..\APS\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\..\APS\apps\le_app\cmd_app;..\..\..\..\APS\apps\le_app\pts_app;..\..\..\project\opl2500\boot_sequence;..\..\..\project\opl2500\include;..\..\..\project\opl2500\lib;..\..\..\project\opl2500\startup;..\..\..\project\common;..\..\..\FreeRtos;..\..\..\FreeRtos\Source\include;..\..\..\FreeRtos\Source\portable\Keil\ARM_CM4F;..\..\..\driver\CMSIS\Device\Opulinks\opl2500\Include;..\..\..\driver\CMSIS\Include;..\..\..\driver\chip;..\..\..\driver\chip\opl2500\camera;..\..\..\driver\chip\opl2500\hal_auxadc;..\..\..\driver\chip\opl2500\hal_dbg_uart;..\..\..\driver\chip\opl2500\hal_dma;..\..\..\driver\chip\opl2500\hal_gpio;..\..\..\driver\chip\opl2500\hal_i2c;..\..\..\driver\chip\opl2500\hal_patch;..\..\..\driver\chip\opl2500\hal_pdm;..\..\..\driver\chip\opl2500\hal_pwm;..\..\..\driver\chip\opl2500\hal_spi;..\..\..\driver\chip\opl2500\hal_system;..\..\..\driver\chip\opl2500\hal_tick;..\..\..\driver\chip\opl2500\hal_tmr;..\..\..\driver\chip\opl2500\hal_uart;..\..\..\driver\chip\opl2500\hal_vic;..\..\..\driver\chip\opl2500\hal_wdt;..\..\..\driver\chip\opl2500\securityipdriver;..\..\..\middleware\netlink;..\..\..\middleware\netlink\at;..\..\..\middleware\netlink\ble_controller_layer\inc;..\..\..\middleware\netlink\cli;..\..\..\middleware\netlink\common\sys_api;..\..\..\middleware\netlink\common\sys_api\rom_if;..\..\..\middleware\netlink\common\sys_ctrl;..\..\..\middleware\netlink\controller_task;..\..\..\middleware\netlink\data_flow;..\..\..\middleware\netlink\diag_task;..\..\..\middleware\netlink\le_stack;..\..\..\middleware\netlink\msg;..\..\..\middleware\netlink\mw_fim;..\..\..\middleware\netlink\mw_ota;..\..\..\middleware\netlink\ps_task;..\..\..\middleware\netlink\wifi_controller_layer;..\..\..\middleware\netlink\wifi_mac;..\..\..\middleware\netlink\wifi_mac\common;..\..\..\middleware\third_party\lwip-2.0.3;..\..\..\middleware\third_party\lwip-2.0.3\lwip\src\include;..\..\..\middleware\third_party\lwip-2.0.3\ports\freertos\include;..\..\..\middleware\third_party\lwip-2.0.3\ports\freertos\netif;..\..\..\middleware\third_party\lwip-2.0.3\ports\rom_if;..\..\..\middleware\third_party\lwip-2.0.3\contrib\apps;..\..\..\middleware\third_party\mbedtls\configs;..\..\..\middleware\third_party\mbedtls\include;..\..\..\middleware\third_party\mbedtls\include\mbedtls;..\..\..\middleware\third_party\mbedtls\port\include;..\..\..\middleware\third_party\tinycrypt\include;..\..\..\middleware\third_party\tinycrypt\include\tinycrypt;..\..\..\apps\le_app\cmd_app;..\..\..\apps\le_app\include;..\..\..\apps\le_app\pts_app;.\src;.\src\components;.\Wi-FiTestSuite\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\opl2500_app_wts_dut.sct
  link misc: --datacompressor off --any_contingency --entry=__Patch_EntryPoint
  group source
    ./: main_patch.c
    ./src/: wts_dut.c cmd_parser.c common_cli.c wifi_cli.c wts_dut_serial.c
    ./src/components/: console.c strerror_util.c
  group object
    ../../../../APS/targets/opl2500/object/: symdefs.o symdefs_fpga_rf.o
    ../../../../APS/targets/opl2500/Output/Objects/: opl2500_patch_aps.lib opl2500_sdk_aps.lib
  group wts_dut
    ./Wi-FiTestSuite/dut/: wfa_dut.c wfa_dut_init.c
    ./Wi-FiTestSuite/lib/: wfa_cmdtbl.c wfa_cs.c wfa_miscs.c wfa_sock.c wfa_tg.c wfa_thr.c wfa_tlv.c wfa_wmmps.c
    ./Wi-FiTestSuite/: wfa_port.c
  group FreeRTOS_POSIX
    ./FreeRTOS-Plus-POSIX/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
target OPL2500_APP_WTS_DUT_fpga (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.1.1
  cpu: as above
  output: opl2500_app_wts_dut_fpga_rf +hex
  AfterMake: .\opl2500_app_aps.bat $L @L
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OPL2500_APS OPL2500_PATCH
  c misc: --preinclude=sys_common.h
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\opl2500_app_wts_dut.sct
  link misc: as above
